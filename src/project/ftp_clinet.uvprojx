# Keil uVision project ftp_clinet.uvprojx, settings and files
target ftp_clinet (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ftp_clinet
  AfterMake: fromelf.exe --bin -o./Obj/ftp_clinet.bin ./Obj/ftp_clinet.axf
  AfterMake: fromelf.exe --i32 -o./Obj/ftp_clinet.hex ./Obj/ftp_clinet.axf
  c flags: Optim=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\FWlib\inc;..\CM3;..\app;..\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8001c00 size 0x4800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ASM
    ../startup/: startup_stm32f10x_hd.s
  group FWlib
    ../FWlib/SRC/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_usart.c
  group CMSYS
    ../CM3/: core_cm3.c system_stm32f10x.c
  group readme
    ./user/: readme.txt
  group app
    ../app/: common.c flash.c ftp.c gprs.c main.c timer.c uart.c updata.c
  group bsp
    ../bsp/: bsp.c
